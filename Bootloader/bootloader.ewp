# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.hex
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: System\linker_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Header
    ./: cipher.h cipher_config.h config.h cpu.h crc.h flash.h flash_config.h m4core.h misc.h nmea.h serial.h serial_config.h timer.h
  group Source
    ./: cipher.c comm.c crc.c flash.c main.c misc.c serial.c timer.c
  group System
    System/: startup_stm32f4xx.s system_stm32f4xx.c
